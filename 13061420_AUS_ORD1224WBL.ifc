Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: ce1b5c1c-e37c-459c-8d6c-dda4c3987c15, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-02T07:23:29+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 13061420_AUS_ORD1224WBL:331B2DRW_AUS_13061420_ORD1224WBL, (2)
In: Default
Type - Material: z_Miele_Design_OBSW, z_Miele_Design_CLST, z_Miele_Design_Glass, Spruce, z_Miele_Connection_Connection_Modul
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 331B2DRW_AUS_13061420_ORD1224WBL; sets with these values: 2
